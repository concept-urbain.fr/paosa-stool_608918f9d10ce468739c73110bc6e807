Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Paosa Tabouret bas.IFC
Time: 2020-07-01T09:25:22
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: PAO-TRESPA-MUL-45X40-001_Default
In: Default Storey
Material: Trespa

# IfcBuildingElementProxy: PAO-MUL-001_Default (2)
In: Default Storey
Name
PAO-MUL-001_Default | PSet_Mass_Property - Mass Measure: 12.5183; Area Measure: 1.03296; Volume Measure: 0.00232207
PAO-MUL-001_Default
