Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Paosa Tabouret haut.IFC
Time: 2020-07-01T09:25:49
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: PAO-MUL-001_Default
In: Default Storey
PSet_Mass_Property - Mass Measure: 17.3391; Area Measure: 1.39521; Volume Measure: 0.00293618

# IfcBeam: PAO-TRESPA-MUL-45X40-001_Default
In: Default Storey
Material: Trespa
